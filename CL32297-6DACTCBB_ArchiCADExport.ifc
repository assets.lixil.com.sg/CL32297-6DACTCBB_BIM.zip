Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2021-06-09T10:27:02
Written by: The EXPRESS Data Manager Version 5.02.0100.09 : 26 Sep 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Default UI

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcDistributionPort
FlowDirection: SOURCE
Pset_DistributionPortPipe - PortNumber: 1; ConnectionType: WELDED
MEPPortPipe - ProfileShape: ROUND; OuterDiameter: 110 mm; ConnectorDiameter: 110 mm; NominalWidth: 110 mm; NominalHeight: 110 mm

# IfcEnergyConversionDevice: Acacia SupaSleek Back To Wall Toilet, AmericanStandard_WCBackToWall_Acacia_(CL32297-6DACTCBB):Acacia SupaSleek Back To Wall Toilet:4525
In: Level 1
Pset_ManufacturerTypeInformation - ModelReference: Acacia SupaSleek Back To Wall Toilet; Manufacturer: American Standard; ProductionYear: 2021
Pset_DistributionFlowElementCommon - Reference: Acacia SupaSleek Back To Wall Toilet
Constraints - Elevation: 0 mm; WasteOffsetAngle: 90 deg; WasteOffsetCalc: 80 mm
Construction - ToiletBowlHole: yes; ToiletLidTop: no; WasteOffsetFloor: 80 mm; WasteOutletFloor: no; WasteOutletWall: yes
Dimensions - Area: 0.514026 m2; Volume: 0.0730445 m3
Identity Data - Mark: 1
Mechanical - System Classification: Sanitary
Other - AssetIdentifier: n/a; BarCode: Please Record On Commissioning.; Category: Plumbing Fixtures; Family: AmericanStandard_WCBackToWall_Acacia_(CL32297-6DACTCBB): Acacia SupaSleek Back To Wall Toilet; Family and Type: AmericanStandard_WCBackToWall_Acacia_(CL32297-6DACTCBB): Acacia SupaSleek Back To Wall Toilet; InstallationDate: Please Record On Commissioning.; SerialNumber: Please Record On Commissioning.; Type: AmericanStandard_WCBackToWall_Acacia_(CL32297-6DACTCBB): Acacia SupaSleek Back To Wall Toilet; Type Id: AmericanStandard_WCBackToWall_Acacia_(CL32297-6DACTCBB): Acacia SupaSleek Back To Wall Toilet; WarrantyStartDate: Please Record On Commissioning.
Phasing - Phase Created: New Construction
Constraints(Type) - Default Elevation: 0 mm
Data(Type) - ConnectionSize: n/a; FlowRate: 3/4.5 litre per flush; InstallationType: Floor Mounted; ProductCategory: Fixtures & Vanities (10); ProductGroup: WC Back To Wall (04); ProductWeight: 30 kg; StyleSegment: Modern; SubCategory: Chinaware/Ceramics (WC) (11)
Identity Data(Type) - Assembly Code: C1030200; Description: Acacia SupaSleek Back To Wall Toilet; Keynote: N13; Manufacturer: American Standard; Model: Acacia SupaSleek Back To Wall Toilet; OmniClass Number: 23.45.05.14.14; OmniClass Title: Sinks/Lavatories; Type Comments: CL32297-6DACTCBB; Type Name: Acacia SupaSleek Back To Wall Toilet; URL: https://www.americanstandard-apac.com/
Model Properties(Type) - _Author: AM; _AuthorizedBy: bimstore; _BimSpecGuid: 0; _BSBibleVersion: 16; _CreatedBy: https://www.bimstore.co; _CurrentRevision: 1; _DistributedBy: https://www.bimstore.co; _ObjectUserGuide: https://www.bimstore.co/products/cl32297-6dactcbb/document/object-user-guide; BIMObjectName: AmericanStandard_WCBackToWall_Acacia_(CL32297-6DACTCBB); NBSDescription: WC pans; NBSNote: n/a; NBSObjectName: American Standard - WC pans; NBSOfficeMasterTag: n/a; NBSReference: 45-35-70/360
Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; ClassificationName: Uniclass2015; ClassificationValue: Pr_40_20_96_18; CodePerformance: n/a; Color: White; Constituents: n/a; CreatedBy: https://www.americanstandard-apac.com/; CreatedOn: 2021-03-01T09:00:00; DocumentationCertificates: https://www.bimstore.co/products/cl32297-6dactcbb/document/product-certificates; DocumentationInstallationGuide: https://www.bimstore.co/products/cl32297-6dactcbb/document/installation-guide; DocumentationLiterature: https://www.bimstore.co/products/cl32297-6dactcbb/document/product-literature; DocumentationMaintenance: https://www.bimstore.co/products/cl32297-6dactcbb/document/maintenance-information; DocumentationTechnical: https://www.bimstore.co/products/cl32297-6dactcbb/document/technical-data-sheet; DurationUnit: Years; ExpectedLife: 0; Family Name: AmericanStandard_WCBackToWall_Acacia_(CL32297-6DACTCBB); Features: n/a; Finish: n/a; Grade: n/a; ManufacturerName: American Standard; Material: Vitreous China; ModelNumber: CL32297-6DACTCBB; ModelReference: Acacia SupaSleek Back To Wall Toilet; ProductionYear: 2021; ReferencedStandard: TIS 792-2011; ReplacementCost: n/a; Shape: n/a; Size: 376 x 555 x 390 mm; TypeName: Acacia SupaSleek Back To Wall Toilet; WarrantyDescription: n/a; WarrantyDurationLabor: 0; WarrantyDurationParts: 0; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: https://www.americanstandard-apac.com/; WarrantyGuarantorParts: https://www.americanstandard-apac.com/
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
